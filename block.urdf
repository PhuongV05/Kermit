Commit message: Update block.urdf

File: block.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- removed link block_2_base_link
- added link body, mass 0.3; collision box size=1.5 1.0 0.1; visual box size=1.5 1.0 0.1
